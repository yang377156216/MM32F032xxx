# Keil uVision project ADC_Interrupt.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: adc_continue_dma_sync +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Device\HALL_LIB\HAL_lib\inc;..\..\..\..\Device\HALL_LIB\Include;..\..\..\..\Device\CMSIS\KEIL_CORE;..\..\HARDWARE\inc;..\..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ../../../../Device/HALL_LIB/Source/: system_MM32F032xx.c
    ../../../../Device/HALL_LIB/Source/KEIL_StartAsm/: startup_MM32F032xx.s
  group HALlib
    ../../../../Device/HALL_LIB/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group USER
    ../../USER/: main.c
  group SYSTEM
    ../../SYSTEM/: delay.c sys.c uart.c
  group HARDWARE
    ../../HARDWARE/: ADC_Interrupt.c
  group README
    ../../: README.TXT
